# IAR project ECE692-7TX.ewp, settings and files
configuration ECE692-7TX (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: --enable_restrict; -DTOOLCHAIN_object; --guard_calls; -DTARGET_KL25Z; -DDEVICE_PORTOUT=1; -D__CORTEX_M0PLUS; -DDEVICE_SEMIHOST=1; -DDEVICE_SLEEP=1; -DTARGET_RELEASE; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DTARGET_FF_ARDUINO; -DTARGET_LIKE_CORTEX_M0; -DTARGET_M0P; -DDEVICE_SPISLAVE=1; -DTARGET_KLXX; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DDEVICE_INTERRUPTIN=1; -DDEVICE_SERIAL=1; -DDEVICE_ANALOGIN=1; -DDEVICE_PORTIN=1; -DTARGET_CORTEX_M; -DARM_MATH_CM0PLUS; -DTARGET_Freescale; -DDEVICE_I2C=1; --preinclude=mbed_config.h; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DDEVICE_PWMOUT=1; -DTARGET_LIKE_MBED; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DMBED_BUILD_TIMESTAMP=1524953809.46; -DTARGET_CORTEX; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; DHT11; nRF24L01P; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device; mbed/TARGET_KL25Z/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_IAR; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_IAR; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -D__CORTEX_M0PLUS; -DARM_MATH_CM0PLUS
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_KL25Z/TOOLCHAIN_IAR/MKL25Z4.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF24L01P
    nRF24L01P/: nRF24L01P.h nRF24L01P.cpp
  group mbed
    mbed/: mbed.h AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CallChain.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h analogin_api.h analogout_api.h can_api.h can_helper.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h toolchain.h us_ticker_api.h wait_api.h AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_KL25Z/: cmsis_armcc.h arm_math.h core_cmSecureAccess.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h MKL25Z4.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h system_MKL25Z4.h MKL25Z4.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/: mbed_rtx.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: PeripheralPins.h PortNames.h gpio_object.h clk_freqs.h objects.h PeripheralPins.h PortNames.h clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h clk_freqs.h gpio_object.h objects.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: PeripheralNames.h PinNames.h device.h PeripheralNames.h PinNames.h device.h PeripheralNames.h PinNames.h device.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device/: cmsis_nvic.h MKL25Z4.h cmsis.h system_MKL25Z4.h
    mbed/drivers/: DigitalInOut.h AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h SerialWireOutput.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: critical_section_api.h Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h ethernet_api.h dma_api.h emac_api.h flash_data.h flash_api.h gpio_irq_api.h gpio_api.h lp_ticker_api.h i2c_api.h itm_api.h pwmout_api.h pinmap.h port_api.h serial_api.h rtc_api.h ticker_api.h sleep_api.h spi_api.h us_ticker_api.h trng_api.h
    mbed/platform/: CriticalSectionLock.h ATCmdParser.h CThunk.h CallChain.h Callback.h CircularBuffer.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h NonCopyable.h PlatformMutex.h ScopedLock.h SingletonPtr.h Stream.h Transaction.h critical.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h rtc_time.h semihost_api.h sleep.h toolchain.h wait_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_IAR/: PeripheralPins.o analogin_api.o analogout_api.o cmain.o gpio_api.o gpio_irq_api.o i2c_api.o mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MKL25Z4.o system_MKL25Z4.o us_ticker.o board.o cmain.o cmsis_nvic.o mbed_overrides.o retarget.o startup_MKL25Z4.o system_MKL25Z4.o board.o cmain.o cmsis_nvic.o mbed_overrides.o retarget.o startup_MKL25Z4.o system_MKL25Z4.o mbed.a mbed.a mbed.a
  group ECE692-7TX
    /tmp/tmpij3Uvr/: mbed_config.h
    ./: TXcode.cpp
  group DHT11
    DHT11/: Dht11.h Dht11.cpp
